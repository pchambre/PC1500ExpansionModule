; Different-first-letter diagnostic: SLOAD (S) and TSAVE (T), each with its
; own dedicated first-letter index slot pointing directly at it -- no entry
; needs to be reached by walking past a preceding same-letter entry. Isolates
; whether the earlier SLOAD/SSAVE failure was about *sharing one index slot*
; (multi-entry same-letter groups) or just "second entry in the table" by
; file position regardless of indexing.

	.area CODE (ABS)
	.org 0x8000

	.db 0x55, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00
	.db 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00
; first-letter index
L8020:
	.dw 0x0000  ; A
	.dw 0x0000  ; B
	.dw 0x0000  ; C
	.dw 0x0000  ; D
	.dw 0x0000  ; E
	.dw 0x0000  ; F
	.dw 0x0000  ; G
	.dw 0x0000  ; H
	.dw 0x0000  ; I
	.dw 0x0000  ; J
	.dw 0x0000  ; K
	.dw 0x0000  ; L
	.dw 0x0000  ; M
	.dw 0x0000  ; N
	.dw 0x0000  ; O
	.dw 0x0000  ; P
	.dw 0x0000  ; Q
	.dw 0x0000  ; R
	.dw SLOAD_ENTRY+2  ; S -- points directly at SLOAD, no walk needed
	.dw TSAVE_ENTRY+2  ; T -- points directly at TSAVE, no walk needed
	.dw 0x0000  ; U
	.dw 0x0000  ; V
	.dw 0x0000  ; W
	.dw 0x0000  ; X
	.dw 0x0000  ; Y
	.dw 0x0000  ; Z
; keyword table (marker/name/code/address per entry)
SLOAD_ENTRY:
	.db 0xD5  ; marker (len=5)
	.ascii "SLOAD"
	.dw 0xE085  ; code
	.dw SLOAD_ROUTINE  ; address
TSAVE_ENTRY:
	.db 0xD5  ; marker (len=5)
	.ascii "TSAVE"
	.dw 0xE086  ; code
	.dw TSAVE_ROUTINE  ; address
	.db 0xD0  ; table terminator
SLOAD_ROUTINE:
	ldi xh,0x76
	ldi xl,0x00
SLOAD_SCAN:
	lda (x)
	eai a,0xFF
	sin x
	cpi xl,0x4E
	bzr SLOAD_SCAN
	cpi xh,0x77
	bzs SLOAD_DONE
	ldi xh,0x77
	ldi xl,0x00
	bch SLOAD_SCAN
SLOAD_DONE:
	pop a
	ldi a,0xCA
	sta (0x784E)  ; CONTPTR_HI
	ldi a,0x92
	sta (0x784F)  ; CONTPTR_LO
	ani (0x764E),0xFE  ; STATUS1 -- clear busy
	ldi xh,0xE2
	ldi xl,0xAA
	stx p
TSAVE_ROUTINE:
	pop a
	ldi a,0xCA
	sta (0x784E)  ; CONTPTR_HI
	ldi a,0x92
	sta (0x784F)  ; CONTPTR_LO
	ani (0x764E),0xFE  ; STATUS1 -- clear busy
	ldi xh,0xE2
	ldi xl,0xAA
	stx p
	.db 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00
	.db 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00
	.db 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00
	.db 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00
	.db 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00
	.db 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00
	.db 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00
	.db 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00
