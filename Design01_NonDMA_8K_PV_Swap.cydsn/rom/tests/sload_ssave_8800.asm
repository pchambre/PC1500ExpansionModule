; Step 1: two entries under the same 'S' index slot, base 8000, PV low --
; SLOAD unchanged from the step 0c file (confirmed dispatching), plus a
; second entry SSAVE immediately after it in the same table, own routine,
; own code value (0xE086, still 0xE0|0 high byte per the confirmed
; formula, distinct low byte from SLOAD's 0x85).

	.area CODE (ABS)
	.org 0x8800

	.db 0x55, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00
	.db 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00
; first-letter index
L8820:
	.dw 0x0000  ; A
	.dw 0x0000  ; B
	.dw 0x0000  ; C
	.dw 0x0000  ; D
	.dw 0x0000  ; E
	.dw 0x0000  ; F
	.dw 0x0000  ; G
	.dw 0x0000  ; H
	.dw 0x0000  ; I
	.dw 0x0000  ; J
	.dw 0x0000  ; K
	.dw 0x0000  ; L
	.dw 0x0000  ; M
	.dw 0x0000  ; N
	.dw 0x0000  ; O
	.dw 0x0000  ; P
	.dw 0x0000  ; Q
	.dw 0x0000  ; R
	.dw KEYWORD_TABLE+2  ; S -- points at SLOAD, the first S-entry
	.dw 0x0000  ; T
	.dw 0x0000  ; U
	.dw 0x0000  ; V
	.dw 0x0000  ; W
	.dw 0x0000  ; X
	.dw 0x0000  ; Y
	.dw 0x0000  ; Z
; keyword table (marker/name/code/address per entry)
KEYWORD_TABLE:
	.db 0xD5  ; marker (len=5)
	.ascii "SLOAD"
	.dw 0xE185  ; code
	.dw SLOAD_ROUTINE  ; address
	.db 0xC5  ; marker (len=5) -- deliberately different high nibble from SLOAD's 0xD5, matching CE-150's own CSAVE marker value, to test whether that matters
	.ascii "SSAVE"
	.dw 0xE1B2  ; code -- low byte widened from adjacent (0x86) to match the kind of gap real CE-150 codes have (e.g. CHAIN's 0xB2 vs CLOAD's 0x89)
	.dw SSAVE_ROUTINE  ; address
	.db 0xD0  ; table terminator
SLOAD_ROUTINE:
	ldi xh,0x76
	ldi xl,0x00
SLOAD_SCAN:
	lda (x)
	eai a,0xFF
	sin x
	cpi xl,0x4E
	bzr SLOAD_SCAN
	cpi xh,0x77
	bzs SLOAD_DONE
	ldi xh,0x77
	ldi xl,0x00
	bch SLOAD_SCAN
SLOAD_DONE:
	pop a
	ldi a,0xCA
	sta (0x784E)  ; CONTPTR_HI
	ldi a,0x92
	sta (0x784F)  ; CONTPTR_LO
	ani (0x764E),0xFE  ; STATUS1 -- clear busy
	ldi xh,0xE2
	ldi xl,0xAA
	stx p
SSAVE_ROUTINE:
	pop a
	ldi a,0xCA
	sta (0x784E)  ; CONTPTR_HI
	ldi a,0x92
	sta (0x784F)  ; CONTPTR_LO
	ani (0x764E),0xFE  ; STATUS1 -- clear busy
	ldi xh,0xE2
	ldi xl,0xAA
	stx p
	.db 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00
	.db 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00
	.db 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00
	.db 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00
	.db 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00
	.db 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00
	.db 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00
	.db 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00
